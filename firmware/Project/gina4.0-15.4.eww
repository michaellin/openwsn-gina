<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\gina4.0-15.4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


